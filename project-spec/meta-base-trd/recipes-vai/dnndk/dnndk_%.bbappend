COMPATIBLE_MACHINE_versal = ".*"
