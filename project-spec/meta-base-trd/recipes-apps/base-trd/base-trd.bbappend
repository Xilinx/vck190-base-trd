SRC_URI = "git://gitenterprise.xilinx.com/PAEG/base-trd-jupyter.git;protocol=https;destsuffix=src/;branch=ckohn/opencv"
SRCREV = "${AUTOREV}"
