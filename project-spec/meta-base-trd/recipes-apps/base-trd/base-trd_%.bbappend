S = "${WORKDIR}/git"

SRC_URI = "git://gitenterprise.xilinx.com/PAEG/base-trd-jupyter.git;protocol=https;branch=master"
SRCREV = "${AUTOREV}"
