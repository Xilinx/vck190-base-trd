SRC_URI = "git://gitenterprise.xilinx.com/PAEG/gst-sdx.git;protocol=https;destsuffix=src/"
SRCREV = "${AUTOREV}"
