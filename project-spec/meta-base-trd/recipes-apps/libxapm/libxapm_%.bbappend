S = "${WORKDIR}/git"

SRC_URI = "git://gitenterprise.xilinx.com/PAEG/libxapm.git;protocol=https;branch=master"
SRCREV = "${AUTOREV}"
