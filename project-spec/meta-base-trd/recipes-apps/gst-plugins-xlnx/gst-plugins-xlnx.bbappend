SRC_URI = " \
	gitsm://gitenterprise.xilinx.com/PAEG/gst-plugins-xlnx.git;protocol=https;branch=dev;destsuffix=src/ \
	"
SRCREV = "${AUTOREV}"
