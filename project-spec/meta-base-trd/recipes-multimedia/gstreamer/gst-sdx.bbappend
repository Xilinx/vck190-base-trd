S = "${WORKDIR}/git"

SRC_URI = "git://gitenterprise.xilinx.com/PAEG/gst-sdx.git;protocol=https;branch=master"
SRCREV = "${AUTOREV}"
