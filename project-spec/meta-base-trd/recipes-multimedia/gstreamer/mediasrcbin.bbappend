BRANCH = "master"
SRC_URI = "git://gitenterprise.xilinx.com/PAEG/mediasrcbin.git;protocol=https;branch=${BRANCH}"
SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git"
