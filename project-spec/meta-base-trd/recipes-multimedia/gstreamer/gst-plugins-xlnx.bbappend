S = "${WORKDIR}/git"

SRC_URI = "gitsm://gitenterprise.xilinx.com/PAEG/gst-plugins-xlnx.git;protocol=https;branch=2019.2/versal"
SRCREV = "${AUTOREV}"
