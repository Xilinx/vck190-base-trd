inherit pypi setuptools3
require python-json5.inc
