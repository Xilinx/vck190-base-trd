RDEPENDS_${PN} += "${PYTHON_PN}-json5"
