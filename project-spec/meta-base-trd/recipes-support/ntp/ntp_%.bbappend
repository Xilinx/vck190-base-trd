FILESEXTRAPATHS_prepend := "${THISDIR}/ntp:"

SRC_URI_append = "file://ntp.conf"
