SUMMARY = "A pythonic library to parse /proc/meminfo"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c726839e1993e1c14e2258963f076056"

SRC_URI[sha256sum] = "d6a014766fe7e0655d06a3116279e5742d49488b3f585693054adee9c540626d"

inherit pypi setuptools3
