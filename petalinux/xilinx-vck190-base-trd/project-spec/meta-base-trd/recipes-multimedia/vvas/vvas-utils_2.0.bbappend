LIC_FILES_CHKSUM = "file://../LICENSE;md5=f7f07bb28ad41b83efb8c4f06ddbaee9"
SRCREV = "${AUTOREV}"
SRC_URI = "git://gitenterprise.xilinx.com/IPS-SSW/vvas.git;protocol=https;branch=master"
