SRCREV = "${AUTOREV}"
SRC_URI = "git://gitenterprise.xilinx.com/IPS-SSW/vvas.git;protocol=https;branch=master"
