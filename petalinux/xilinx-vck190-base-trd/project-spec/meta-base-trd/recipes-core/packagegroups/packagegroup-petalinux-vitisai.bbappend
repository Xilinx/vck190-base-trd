COMPATIBLE_MACHINE_versal = ".*"
RDEPENDS_${PN}_remove = "dnndk"
